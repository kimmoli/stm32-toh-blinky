# Keil uVision project Blinky.uvprojx, settings and files
target STM32F401 RAM (ARM-ADS)
  device: STM32F401VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(84000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000, VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
  group Flash OPT
    ./: STM32F401xx_OPT.s
  group Source Files
    ./: Blinky.c led.c led.h
  group Documentation
    ./: Abstract.txt
  group ::Device
    RTE/Device/STM32F401VC/: RTE_Device.h startup_stm32f401xx.s system_stm32f4xx.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/RTE_Driver/: GPIO_STM32F4xx.c
    RTE/Device/STM32F401RB/: RTE_Device.h startup_stm32f401xx.s system_stm32f4xx.c
target STM32F401 Flash (ARM-ADS)
  device: STM32F401RB STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(84000000) ELITTLE
  output: Blinky +hex
  c flags: Optim=1
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM32F401 OPT (ARM-ADS)
  device: STM32F401VC STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 3.30.0, Device:GPIO 1.0.1, Device:Startup 1.3.1
